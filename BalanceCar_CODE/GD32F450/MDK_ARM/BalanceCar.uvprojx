# Keil uVision project BalanceCar.uvprojx, settings and files
target GD32F450VGT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Objects/BalanceCar.bin ./Objects/BalanceCar.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: GD32F450
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\APP;..\..\OS;..\BSP_F450;..\..\GD32F450;..\INT;..\SYS;..\..\APP\DataScope;..\MPU;..\MPU\DMP;..\LCD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../APP/: main.cpp TASK_MPU.cpp TASK_BALANCE.cpp TASK_SCREEN.cpp TASK_MUSIC.cpp OS_TIMER.cpp
  group BSP_F450
    ../BSP_F450/: BSP_F450.cpp IO_F450.cpp ADC_F450.cpp TIM_F450.cpp UART_F450.cpp
    ../MPU/: MPU_IIC.cpp MPU9250.cpp
    ../MPU/DMP/: inv_mpu.cpp inv_mpu_dmp_motion_driver.cpp
    ../LCD/: LCD_SPI.cpp LCD.cpp
  group INT
    ../INT/: gd32f4xx_it.c
  group SYS
    ../SYS/: systick.c
  group OS
    ../../OS/: OS.cpp
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group LIB_F450
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group DataScope
    ../../APP/DataScope/: DataScope_DP.C
  group Doc
    ../../: README.md
software components: CMSIS:CORE 5.5.0, RTOS:kernel 3.1.5
